# Keil uVision project BH-F429.uvprojx, settings and files
target LwIP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F439IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Charge13 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\USER;..\..\USER\Bsp\ETH;..\..\USER\App;..\..\USER\lwip-1.4.1\port\arch;..\..\USER\lwip-1.4.1\port\Standalone;..\..\USER\lwip-1.4.1\port;..\..\USER\lwip-1.4.1\src\include\ipv4;..\..\USER\lwip-1.4.1\src\include\lwip;..\..\USER\lwip-1.4.1\src\include\netif;..\..\USER\lwip-1.4.1\src\include;..\..\USER\lcd;..\..\USER\flash;..\..\USER\FATFS;..\..\USER\FATFS\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fmc.c
  group USER
    ../../USER/: main.c stm32f4xx_it.c dwgl_global.c dwgl_function.c dwgl_bsp_gpio.c AsciiLib_65k.c HzLib_65k.c dwgl_tft.c dwgl_tim.c dwgl_memp.c dwgl_fat.c
    ../../USER/App/: netconf.c udp_demo.c tcp_demo.c
    ../../USER/lcd/: dwgl_WB_LCD.c
    ../../USER/adc/: bsp_adc.c
    ../../USER/flash/: bsp_spi_flash.c
  group BSP
    ../../USER/Bsp/usart/: bsp_debug_usart.c
    ../../USER/Bsp/key/: bsp_key.c
    ../../USER/Bsp/systick/: bsp_SysTick.c
    ../../USER/Bsp/led/: bsp_led.c
    ../../USER/Bsp/ETH/: stm32f429_eth.c stm32f429_phy.c
    ../../USER/sdio/: bsp_sdio_sd.c
  group LwIP_src_api
    ../../USER/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP_src_core_ipv4
    ../../USER/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP_src_core
    ../../USER/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LwIP_src_netif
    ../../USER/lwip-1.4.1/src/netif/: etharp.c
  group LwIP_port
    ../../USER/lwip-1.4.1/port/Standalone/: ethernetif.c
  group DOC
    ../../: 必读说明.txt
  group FatFs
    ../../USER/FATFS/: diskio.c ff.c
    ../../USER/FATFS/option/: ccsbcs.c
